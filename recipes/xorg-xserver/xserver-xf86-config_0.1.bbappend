PRINC = "6"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
