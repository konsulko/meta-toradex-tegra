FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-lxterminal.c-fix-garbled-titlebar.patch \
"
