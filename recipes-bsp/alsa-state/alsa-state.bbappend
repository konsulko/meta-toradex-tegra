PRINC = "6"

FILESEXTRAPATHS_prepend := "${THISDIR}/alsa-state/:"
