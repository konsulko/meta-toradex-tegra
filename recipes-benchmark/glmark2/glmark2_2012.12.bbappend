#build it only for OpenGL ES
PACKAGECONFIG = "gles2"