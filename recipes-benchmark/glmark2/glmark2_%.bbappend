#build it only for OpenGL ES
PACKAGECONFIG_tegra = "x11-gles2"